options:
  parameters:
    generate_options: no_gui
    id: dme_receiver
    output_language: python
    run_options: run
    title: Daniel Estevez
  states: {}

blocks:
- name: npolyphase
  id: variable
  parameters:
    value: '128'
  states: {}
- name: polyphase_double_pulse
  id: variable
  parameters:
    value: np.concatenate((polyphase_pulse, np.zeros(pulse_spacing_polysamples))) + np.concatenate((np.zeros(pulse_spacing_polysamples), polyphase_pulse))
  states: {}
- name: polyphase_pulse
  id: variable
  parameters:
    value: np.exp(-(np.arange(pulse_ntaps * npolyphase) - pulse_ntaps * npolyphase // 2)**2 / (2 * (pulse_sigma * samp_rate * npolyphase)**2))
  states: {}
- name: polyphase_taps
  id: variable
  parameters:
    value: polyphase_double_pulse * np.max(polyphase_double_pulse) / np.sum(polyphase_double_pulse**2) * npolyphase
  states: {}
- name: pulse_ntaps
  id: variable
  parameters:
    value: '27'
  states: {}
- name: pulse_sigma
  id: variable
  parameters:
    value: pulse_width / (2 * np.sqrt(2 * np.log(2)))
  states: {}
- name: pulse_spacing
  id: variable
  parameters:
    value: '12e-6'
  states: {}
- name: pulse_spacing_polysamples
  id: variable
  parameters:
    value: round(pulse_spacing * samp_rate * npolyphase)
  states: {}
- name: pulse_spacing_tolerance
  id: variable
  parameters:
    value: '0.5e-6'
  states: {}
- name: pulse_taps
  id: variable
  parameters:
    value: pulse_taps_unnormalized * np.max(pulse_taps_unnormalized) / np.sum(pulse_taps_unnormalized**2)
  states: {}
- name: pulse_taps_unnormalized
  id: variable
  parameters:
    value: np.exp(-(np.arange(pulse_ntaps) - pulse_ntaps//2)**2 / (2 * (pulse_sigma * samp_rate)**2))
  states: {}
- name: pulse_width
  id: variable
  parameters:
    value: '3.5e-6'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2500000'
  states: {}
- name: threshold
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '10'
  states: {state: disabled}
- name: threshold
  id: variable
  parameters:
    value: '10'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: pulse_ntaps//2
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /mnt/CNR_VOR_ground_2024-07-13.sigmf-data
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: dme_double_pulse_coalsce_0
  id: dme_double_pulse_coalsce
  parameters:
    delay: round(0.5 * pulse_spacing * samp_rate)
    max_distance: int(np.ceil((pulse_spacing + pulse_spacing_tolerance) * samp_rate))
    min_distance: int((pulse_spacing - pulse_spacing_tolerance) * samp_rate)
  states: {}
- name: dme_polyphase_fine_estimate_0
  id: dme_polyphase_fine_estimate
  parameters:
    num_branches: npolyphase
    polyphase_taps: polyphase_taps
    window_size: int(2 * pulse_width * samp_rate)
  states: {}
- name: dme_pulse_detector_0
  id: dme_pulse_detector
  parameters:
    noise_alpha: '1e-5'
    threshold: threshold
    window_size: pulse_ntaps
  states: {}
- name: dme_tag_file_sink_0
  id: dme_tag_file_sink
  parameters:
    mf_file: CNR_VOR_ground_2024-07-13_mf.c64
    offset_file: CNR_VOR_ground_2024-07-13_offsets.f64
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: pulse_taps
    type: ccf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: int(samp_rate * 1e-3)
    srate: samp_rate
    tr_delay: '100e-6'
    tr_level: '0'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"pulse"'
    type: complex
  states: {state: disabled}

connections:
- [blocks_complex_to_mag_squared_0, '0', dme_pulse_detector_0, '1']
- [blocks_delay_0, '0', dme_pulse_detector_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_delay_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_throttle2_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', fir_filter_xxx_0, '0']
- [blocks_throttle2_0, '0', blocks_delay_0, '0']
- [blocks_throttle2_0, '0', fir_filter_xxx_0, '0']
- [dme_double_pulse_coalsce_0, '0', dme_polyphase_fine_estimate_0, '0']
- [dme_polyphase_fine_estimate_0, '0', dme_tag_file_sink_0, '0']
- [dme_polyphase_fine_estimate_0, '0', qtgui_time_sink_x_0_0, '0']
- [dme_pulse_detector_0, '0', dme_double_pulse_coalsce_0, '0']
- [fir_filter_xxx_0, '0', blocks_complex_to_mag_squared_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
